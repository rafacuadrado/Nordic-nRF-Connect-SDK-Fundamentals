## lesson4/l4_e3/build/l4_e3/Kconfig/boards/Kconfig.defconfig
```kconfig
# Load Zephyr board defconfig descriptions.
osource "C:/ncs/v3.2.3/zephyr/boards/nordic/nrf5340dk/Kconfig.defconfig"
```
